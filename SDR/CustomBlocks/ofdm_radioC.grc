<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_radio_2</value></param>
<param><key>category</key><value>custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
<param><key>title</key><value>OFDM Radio 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>backoff_db</value></param>
<param><key>value</key><value>-15.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>USRP device args</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>''</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>open</key><value>enable</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_1</value></param>
<param><key>open</key><value>enable</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10.0**(1.0*backoff_db/10.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_1</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"length"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>length</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>rolloff</key><value>0 + 4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enable</value></param>
<param><key>label</key><value>Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>foo_burst_tagger</key>
<param><key>id</key><value>foo_burst_tagger_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>mult</key><value>1</value></param>
<param><key>tag_name</key><value>pmt.intern("length")</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>pad_front</key><value>16*4 * 4</value></param>
<param><key>pad_tail</key><value>16</value></param>
</block>
<block>
<key>mac_burst_tagger</key>
<param><key>id</key><value>mac_burst_tagger_0</value></param>
<param><key>drop_residue</key><value>True</value></param>
<param><key>mult</key><value>1</value></param>
<param><key>pad_front</key><value>256</value></param>
<param><key>pad_rear</key><value>16</value></param>
<param><key>tag_name</key><value>'length'</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Front: 128 is too short, Tail: 8 is adequate</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bb_rx</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bb_tx</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>msg_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>msg_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ant</value></param>
<param><key>label</key><value>RX antenna</value></param>
<param><key>short_id</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'TX/RX'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>RX freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lo_offset</value></param>
<param><key>label</key><value>RX LO offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>label</key><value>TX freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>65</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_lo_offset</value></param>
<param><key>label</key><value>TX LO offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(tx_freq, 10e6)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, 10e6)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_1</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blks2_valve_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>pdus</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_1</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>foo_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>mac_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_burst_tagger_0</source_block_id><sink_block_id>foo_packet_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mac_burst_tagger_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_ofdm_rx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
