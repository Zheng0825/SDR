<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>protocolhopping</value></param>
<param><key>category</key><value>custom</value></param>
<param><key>description</key><value>This radio block should allow to switch between OFDM and GMSK</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
<param><key>title</key><value>protocol hopping</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>backoff_db</value></param>
<param><key>value</key><value>-15.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>access_code_threshold</value></param>
<param><key>label</key><value>Access code threshold</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>TX BB amp</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>USRP device args</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>''</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>enabletx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>ampl</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0 if enabletx else 1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>enablerx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3</value></param>
<param><key>const</key><value>0 if enablerx else 1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
</block>
<block>
<key>digital_qam_demod</key>
<param><key>id</key><value>digital_qam_demod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>16</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
</block>
<block>
<key>digital_qam_mod</key>
<param><key>id</key><value>digital_qam_mod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>16</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enablerx</value></param>
<param><key>label</key><value>Enable RX</value></param>
<param><key>short_id</key><value>e</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enabletx</value></param>
<param><key>label</key><value>Enable TX</value></param>
<param><key>short_id</key><value>e</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>mac_burst_tagger</key>
<param><key>id</key><value>mac_burst_tagger_0_0</value></param>
<param><key>drop_residue</key><value>True</value></param>
<param><key>mult</key><value>samps_per_sym*8</value></param>
<param><key>pad_front</key><value>128*0 + 0</value></param>
<param><key>pad_rear</key><value>32*0 + 16</value></param>
<param><key>tag_name</key><value>'length'</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>mac_packet_deframer</key>
<param><key>id</key><value>mac_packet_deframer_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>access_code_threshold</value></param>
</block>
<block>
<key>mac_packet_deframer</key>
<param><key>id</key><value>mac_packet_deframer_0_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>access_code_threshold</value></param>
</block>
<block>
<key>mac_packet_framer</key>
<param><key>id</key><value>mac_packet_framer_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>postamble</key><value>''.join(['\x00']*(16/8/samps_per_sym)*0)</value></param>
<param><key>preamble</key><value>''.join(['\x55']*((256*1)/8/samps_per_sym))</value></param>
<param><key>rotate_whitener_offset</key><value>False</value></param>
<param><key>whiten</key><value>True</value></param>
<param><key>whitener_offset</key><value>0</value></param>
</block>
<block>
<key>mac_packet_to_pdu</key>
<param><key>id</key><value>mac_packet_to_pdu_0</value></param>
<param><key>dewhiten</key><value>True</value></param>
<param><key>log_invalid</key><value>False</value></param>
<param><key>output_invalid</key><value>False</value></param>
</block>
<block>
<key>mac_packet_to_pdu</key>
<param><key>id</key><value>mac_packet_to_pdu_0_0</value></param>
<param><key>dewhiten</key><value>True</value></param>
<param><key>log_invalid</key><value>False</value></param>
<param><key>output_invalid</key><value>False</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Front: 128 is too short, Tail: 8 is adequate</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bb_rx</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bb_tx</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>msg_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>msg_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ant</value></param>
<param><key>label</key><value>RX antenna</value></param>
<param><key>short_id</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'TX/RX'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>RX freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lo_offset</value></param>
<param><key>label</key><value>RX LO offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_sym</value></param>
<param><key>label</key><value>Samples/symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>label</key><value>TX freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>65</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_lo_offset</value></param>
<param><key>label</key><value>TX LO offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(tx_freq, tx_lo_offset)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>args</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, 10e6)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>mac_burst_tagger_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>digital_gmsk_demod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>digital_qam_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_gmsk_mod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_qam_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>mac_packet_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0_0</source_block_id><sink_block_id>mac_packet_deframer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_qam_demod_0</source_block_id><sink_block_id>mac_packet_deframer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_qam_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mac_burst_tagger_0_0</source_block_id><sink_block_id>pad_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mac_burst_tagger_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mac_packet_deframer_0</source_block_id><sink_block_id>mac_packet_to_pdu_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>mac_packet_deframer_0_0</source_block_id><sink_block_id>mac_packet_to_pdu_0_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>mac_packet_framer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>mac_packet_to_pdu_0</source_block_id><sink_block_id>pad_sink_3_0</sink_block_id><source_key>pdu</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mac_packet_to_pdu_0_0</source_block_id><sink_block_id>pad_sink_3_0</sink_block_id><source_key>pdu</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>mac_packet_framer_0</sink_block_id><source_key>0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
