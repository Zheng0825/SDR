<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>simple_trx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>enablerx</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Enable RX</value></param>
<param><key>labels</key><value>["GMSK", "GFSK"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>enabletx</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Enable TX</value></param>
<param><key>labels</key><value>["GMSK", "GFSK"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>radio_addr</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>88</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Local address</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value></value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>user_rx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>rx_gain</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>max</key><value>90</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>user_tx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>tx_gain</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>max</key><value>90</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>TX BB amp</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>USRP device args</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>''</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arq_timeout</value></param>
<param><key>label</key><value>ARQ timeout</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.1*0 + 0.04</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("T")</value></param>
<param><key>period</key><value>1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>10000</value></param>
<param><key>max_iter</key><value>40000/4</value></param>
<param><key>scale</key><value>1./10000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>mtu</value></param>
<param><key>port</key><value>port</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>iface</value></param>
<param><key>mtu</key><value>mtu*0 + 1514</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dest_addr</value></param>
<param><key>label</key><value>Destination address</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>-1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iface</value></param>
<param><key>label</key><value>Interface name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'tun0'</value></param>
</block>
<block>
<key>mac_802_3_tracker</key>
<param><key>id</key><value>mac_802_3_tracker</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>mac_virtual_channel_decoder</key>
<param><key>id</key><value>mac_virtual_channel_decoder_0</value></param>
<param><key>channel_count</key><value>3</value></param>
<param><key>chan_map</key><value>[0, 1]</value></param>
</block>
<block>
<key>mac_virtual_channel_encoder</key>
<param><key>id</key><value>mac_virtual_channel_encoder_0</value></param>
<param><key>arq</key><value>True</value></param>
<param><key>chan_tracker</key><value></value></param>
<param><key>dest_addr</key><value>-1</value></param>
<param><key>chan_id</key><value>0</value></param>
<param><key>mtu</key><value>mtu</value></param>
<param><key>prepend_dummy</key><value>False</value></param>
</block>
<block>
<key>mac_virtual_channel_encoder</key>
<param><key>id</key><value>mac_virtual_channel_encoder_0_0</value></param>
<param><key>arq</key><value>True</value></param>
<param><key>chan_tracker</key><value>mac_802_3_tracker</value></param>
<param><key>dest_addr</key><value>-1</value></param>
<param><key>chan_id</key><value>1</value></param>
<param><key>mtu</key><value>mtu</value></param>
<param><key>prepend_dummy</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_arq_attempts</value></param>
<param><key>label</key><value>Max ARQ attempts</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5 * 2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mtu</value></param>
<param><key>label</key><value>MTU</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ogradio_addr</value></param>
<param><key>label</key><value>Local address</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ogrx_freq</value></param>
<param><key>label</key><value>RX freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ogtx_freq</value></param>
<param><key>label</key><value>TX freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>TCP port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>12345</value></param>
</block>
<block>
<key>protocolhopping</key>
<param><key>id</key><value>protocolhopping_0</value></param>
<param><key>access_code_threshold</key><value>0 + 12 + 4*0</value></param>
<param><key>enablerx</key><value>1</value></param>
<param><key>enabletx</key><value>1</value></param>
<param><key>rx_lo_offset</key><value>rx_lo_offset</value></param>
<param><key>rx_ant</key><value>rx_antenna</value></param>
<param><key>rx_freq</key><value>rx_freq</value></param>
<param><key>rx_gain</key><value>user_rx_gain</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>samps_per_sym</key><value>samps_per_sym</value></param>
<param><key>ampl</key><value>ampl</value></param>
<param><key>tx_lo_offset</key><value>tx_lo_offset</value></param>
<param><key>tx_freq</key><value>tx_freq</value></param>
<param><key>tx_gain</key><value>user_tx_gain</value></param>
<param><key>args</key><value>args</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_antenna</value></param>
<param><key>label</key><value>RX antenna</value></param>
<param><key>short_id</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>TX/RX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>65-20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lo_offset</value></param>
<param><key>label</key><value>RX LO offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_sym</value></param>
<param><key>label</key><value>Samples/symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>simple_mac</key>
<param><key>id</key><value>simple_mac_1</value></param>
<param><key>timeout</key><value>arq_timeout</value></param>
<param><key>backoff_randomness</key><value>0.05</value></param>
<param><key>exp_backoff</key><value>False</value></param>
<param><key>broadcast_interval</key><value>2.0</value></param>
<param><key>expire_on_arq_failure</key><value>False</value></param>
<param><key>addr</key><value>radio_addr</value></param>
<param><key>maximum_attempts</key><value>max_arq_attempts</value></param>
<param><key>node_expiry_delay</key><value>10.0</value></param>
<param><key>only_send_if_alive</key><value>False</value></param>
<param><key>prepend_dummy</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>45</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_lo_offset</value></param>
<param><key>label</key><value>TX LO offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>bb_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>bb_rx</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0.0001</value></param>
<param><key>title</key><value>RX</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0.02</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>simple_mac_1</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>mac_virtual_channel_encoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0</source_block_id><sink_block_id>mac_virtual_channel_encoder_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out0</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_decoder_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>out1</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_decoder_0</source_block_id><sink_block_id>mac_802_3_tracker</sink_block_id><source_key>out1</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_decoder_0</source_block_id><sink_block_id>blocks_message_debug_0_0_1</sink_block_id><source_key>out2</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_encoder_0</source_block_id><sink_block_id>simple_mac_1</sink_block_id><source_key>out</source_key><sink_key>from_app_arq</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_encoder_0_0</source_block_id><sink_block_id>simple_mac_1</sink_block_id><source_key>out</source_key><sink_key>from_app_arq</sink_key></connection>
<connection><source_block_id>protocolhopping_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>protocolhopping_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>protocolhopping_0</source_block_id><sink_block_id>simple_mac_1</sink_block_id><source_key>msg_out</source_key><sink_key>from_radio</sink_key></connection>
<connection><source_block_id>simple_mac_1</source_block_id><sink_block_id>mac_virtual_channel_decoder_0</sink_block_id><source_key>to_app</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>simple_mac_1</source_block_id><sink_block_id>protocolhopping_0</sink_block_id><source_key>to_radio</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
